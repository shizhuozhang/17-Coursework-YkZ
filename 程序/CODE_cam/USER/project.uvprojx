# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\USART;..\HARDWARE;..\HARDWARE\TIMER;..\HARDWARE\IO;..\HARDWARE\PWMOUT;..\HARDWARE\DMA_USART;..\HARDWARE\PID_CONTROL;..\USER;..\HARDWARE\MPU6500
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/: H_define.c H_define.h
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/PWMOUT/: pwm.c
    ../HARDWARE/DMA_USART/: DMA_USART.c
    ../HARDWARE/PID_CONTROL/: PidContoller.c
    ../HARDWARE/MPU6500/: mpu6500.c ahrs.c mpu6500_spi.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
